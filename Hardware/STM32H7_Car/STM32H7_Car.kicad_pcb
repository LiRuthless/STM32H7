# Repository LiRuthless/STM32H7

## KiCad design Hardware/STM32H7_Car/STM32H7_Car.kicad_pcb

Parts:
1: U?; STM32H7xx Core Board
C1, C6, C7, C13, C14: 22u; C_0805_2012Metric
C2, C5, C9, C12, C19: 0.1u; C_0603_1608Metric
C3, C10: 22p; C_0603_1608Metric
C4: 10n; C_0603_1608Metric
C8: 10u; C_0805_2012Metric
C11: 4.7n; C_0603_1608Metric
C15, C16, C17, C18: 1u; C_0603_1608Metric
J1: L_MOTOR; PinHeader_1x03_P2.54mm_Vertical
J2: R_MOTOR; PinHeader_1x03_P2.54mm_Vertical
J3: L_ENC; PinHeader_1x04_P1.27mm_Vertical
J4: R_ENC; PinHeader_1x04_P1.27mm_Vertical
J5: L_ADC; PinHeader_1x07_P2.54mm_Vertical
J6: IR_ADC; PinHeader_1x07_P2.54mm_Vertical
J7: IMU; PinHeader_1x06_P2.54mm_Vertical
J8: OLED; PinHeader_1x08_P2.54mm_Vertical
J9: WIFI; PinHeader_2x04_P2.54mm_Vertical
J10: USART1; PinHeader_1x04_P2.54mm_Vertical
J11: DL1B; PinHeader_1x05_P2.54mm_Vertical
J12: M_MOTOR; PinHeader_1x03_P2.54mm_Vertical
J13: USART2; PinHeader_1x04_P2.54mm_Vertical
J14: SPI_NC; PinHeader_1x08_P2.54mm_Vertical
J15: XT30PW-M; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J16, J17, J18: 5V; PinHeader_1x02_P2.54mm_Vertical
L1: 3.3u; L_Molded_5x5mm_FEXL0530A_ZD0520; LCSC C5378512
L2: 2.2u; L_Molded_5x5mm_FEXL0530A_ZD0520; LCSC C46956540
R1, R6: 10k; R_0603_1608Metric
R2: 124k; R_0603_1608Metric
R3, R5: 22.1k; R_0603_1608Metric
R4: 73.2k; R_0603_1608Metric
R7, R8: 100k; R_0603_1608Metric
R9: 27k; R_0603_1608Metric
U1: TPS54627DDAR; TI_DDA0008A_SO-PowerPAD-8; LCSC C398919
U2: TPS54325PWPR; TI_PWP0014A_HTSSOP-14-EP; LCSC C43717
U3: TPS7A2033PDBVR; SOT-23-5; LCSC C2862740
U4: ESP32-S3-DevKitM-1

Connections:
+3.3V: C10.1, C13.1, C14.1, J3.1, J4.1, J6.1, J8.1, J9.1, J10.1, J13.1, J14.1, L2.2, R4.1, U2.1 (VO); also elsewhere on the board
+3.3VA: C18.1, J5.1, J7.1, U3.5 (OUT); also elsewhere on the board
+5V: 1.41 (5V), 1.87 (5V), C3.1, C6.1, C7.1, C8.2, C9.2, C17.1, J11.1, J16.1, J17.1, J18.1, L1.2, R2.1, R6.1, U2.13 (VIN), U2.14 (VCC), U3.1 (IN), U3.3 (EN), U4.21 (5V)
+12V: C1.2, C2.2, J15.1, R1.1, R8.1, U1.8 (VIN)
/IR_ADC: 1.26 (PC4), J6.6; also elsewhere on the board
/IR_IO_1: 1.6 (PE4), J6.2; also elsewhere on the board
/IR_IO_2: 1.8 (PE6), J6.3; also elsewhere on the board
/IR_IO_3: 1.85 (PE0), J6.4; also elsewhere on the board
/IR_IO_4: 1.86 (PE1), J6.5; also elsewhere on the board
/L_ADC_1: 1.12 (PC0), J5.3; also elsewhere on the board
/L_ADC_2: 1.11 (PC1), J5.4; also elsewhere on the board
/L_ADC_3: 1.22 (PA4), J5.5; also elsewhere on the board
/L_ADC_4: 1.25 (PC5), J5.6; also elsewhere on the board
/NC_ADC: 1.21 (PA5), 1.27 (PB1)
/NC_PWM_1: 1.84 (PB9)
/NC_PWM_2: 1.83 (PB8)
/RX: 1.63 (PA10), J10.3
/RX_esp: J13.3, U4.27 (GPIO44)
/SW_SPI_CS: 1.71 (PD1)
/SW_SPI_MISO: 1.70 (PD0)
/SW_SPI_MOSI: 1.74 (PD4)
/SW_SPI_SCK: 1.75 (PD5)
/TX: 1.62 (PA9), J10.2
/TX_esp: J13.2, U4.28 (GPIO43)
/batt_ADC: 1.28 (PB0), C19.2, R8.2, R9.1
/dl1b_SCL: 1.40 (PB10), J11.3
/dl1b_SDA: 1.39 (PB11), J11.4
/dl1b_XS: 1.32 (PE8), J11.5
/fan_PWM: 1.23 (PA7), J12.1
/imu_CS: 1.73 (PD3), J7.5; also elsewhere on the board
/imu_MISO: 1.5 (PE5), J7.4; also elsewhere on the board
/key_ADC_1: 1.20 (PA2)
/key_ADC_2: 1.19 (PA3)
/l_ENC_A: 1.17 (PA1), J3.2; also elsewhere on the board
/l_ENC_B: 1.18 (PA0), J3.3; also elsewhere on the board
/l_motor_DIR: 1.29 (PE7), J1.3
/l_motor_PWM: 1.24 (PA6), J1.1
/lcd_BLK: 1.34 (PE10)
/lcd_CS: 1.33 (PE11)
/lcd_DC: 1.35 (PE13), J8.4
/led: 1.80 (PB5)
/oled _BLK: 1.51 (PD10), J8.6
/oled _CS: 1.31 (PE9), J8.5
/oled _RST: 1.50 (PD9), J8.7
/r_ENC_A: 1.57 (PC6), J4.2; also elsewhere on the board
/r_ENC_B: 1.58 (PC7), J4.3; also elsewhere on the board
/r_motor_DIR: 1.37 (PE15), J2.3
/r_motor_PWM: 1.55 (PD14), J2.1
/spi4_MOSI: 1.38 (PE14), J7.3, J8.3; also elsewhere on the board
/spi4_SCL: 1.36 (PE12), J7.2, J8.2; also elsewhere on the board
/spi_CS1: J14.3, U4.37 (GPIO34)
/spi_CS2: J14.2, U4.38 (GPIO33)
/spi_MISO: J14.6, U4.34 (GPIO37)
/spi_MOSI: J14.4, U4.36 (GPIO35)
/spi_NC: J14.7, U4.33 (GPIO38)
/spi_SCK: J14.5, U4.35 (GPIO36)
/stm32_RST: 1.9 (NRST), U4.40 (GPIO21)
/wifi_CS: 1.45 (PB12), J9.2, U4.12 (GPIO10)
/wifi_INT: 1.66 (PA15), J9.6, U4.16 (GPIO14)
/wifi_MISO: 1.47 (PB14), J9.4, U4.15 (GPIO13)
/wifi_MOSI: 1.48 (PB15), J9.5, U4.13 (GPIO11)
/wifi_RST: 1.56 (PD15), J9.7, U4.24 (EN)
/wifi_SCK: 1.46 (PB13), J9.3, U4.14 (GPIO12)
GND: 1.2 (GND), 1.16 (GND), 1.43 (GND), 1.44 (GND), 1.88 (GND), C1.1, C2.1, C4.1, C6.2, C7.2, C8.1, C9.1, C11.1, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C19.1, J1.2, J2.2, J3.4, J4.4, J5.2, J5.7, J6.7, J7.6, J8.8, J9.8, J10.4, J11.2, J12.2, J13.4, J14.8, J15.2, J16.2, J17.2, J18.2, R3.2, R5.2, R9.2, U1.5 (GND), U1.9 (PAD), U2.5 (GND), U2.8 (PGND1), U2.9 (PGND2), U2.15 (PAD), U3.2 (GND), U4.22 (GND), U4.23 (GND); also elsewhere on the board
unnamed: R1.2, U1.1 (EN)
unnamed: C4.2, U1.4 (SS)
unnamed: C5.2, L1.1, U1.6 (SW)
unnamed: C5.1, U1.7 (VBST)
unnamed: C3.2, R2.2, R3.1, U1.2 (VFB)
unnamed: C16.2, U1.3 (VREG5)
unnamed: R6.2, U2.7 (EN)
unnamed: R7.1, U2.6 (PG)
unnamed: C11.2, U2.4 (SS)
unnamed: C12.2, L2.1, U2.10 (SW1), U2.11 (SW2)
unnamed: C12.1, U2.12 (VBST)
unnamed: C10.2, R4.2, R5.1, U2.2 (VFB)
unnamed: C15.1, R7.2, U2.3 (VREG5)

Notes on the sheet:
5V转3V3
5V转3V3A
12V转5V

Board: 2 copper layers, 58 parts (1 on the bottom side), 66 nets, no tracks yet.

Other parts of the board:
J3A, J4A: FPC-SMD_4P-P1.00_JS_AFA01-S04FCA-00
J5A, J6A: FPC-SMD_XUNPU_FPC-1.0FX-7PWCR-H20
J7A: FPC-SMD_6P-P1.00_AFA01-S06

Their connections:
+3.3V: J3A.1, J4A.1, J6A.1; also elsewhere on the board
+3.3VA: J5A.1, J7A.1; also elsewhere on the board
/IR_ADC: J6A.6; also elsewhere on the board
/IR_IO_1: J6A.2; also elsewhere on the board
/IR_IO_2: J6A.3; also elsewhere on the board
/IR_IO_3: J6A.4; also elsewhere on the board
/IR_IO_4: J6A.5; also elsewhere on the board
/L_ADC_1: J5A.3; also elsewhere on the board
/L_ADC_2: J5A.4; also elsewhere on the board
/L_ADC_3: J5A.5; also elsewhere on the board
/L_ADC_4: J5A.6; also elsewhere on the board
/imu_CS: J7A.5; also elsewhere on the board
/imu_MISO: J7A.4; also elsewhere on the board
/l_ENC_A: J3A.2; also elsewhere on the board
/l_ENC_B: J3A.3; also elsewhere on the board
/r_ENC_A: J4A.2; also elsewhere on the board
/r_ENC_B: J4A.3; also elsewhere on the board
/spi4_MOSI: J7A.3; also elsewhere on the board
/spi4_SCL: J7A.2; also elsewhere on the board
GND: J3A.4, J4A.4, J5A.2, J5A.7, J6A.7, J7A.6; also elsewhere on the board

## Code that names these connections

File SmartCar/SmartCar.ioc (part):

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Mcu.Name=STM32H743VITx
Mcu.Package=LQFP100
Mcu.UserName=STM32H743VITx
PA0.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0.GPIO_Label=ENC_L_A
PA0.GPIO_PuPd=GPIO_PULLUP
PA0.Signal=S_TIM5_CH1
PA1.GPIOParameters=GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=ENC_L_B
PA1.GPIO_PuPd=GPIO_PULLUP
PA1.Signal=S_TIM5_CH2
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13\ (JTMS/SWDIO).Mode=Serial_Wire
PA13\ (JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14\ (JTCK/SWCLK).Mode=Serial_Wire
PA14\ (JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15\ (JTDI).GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PA15\ (JTDI).GPIO_Label=WIFI_INT
PA15\ (JTDI).GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA15\ (JTDI).GPIO_PuPd=GPIO_PULLUP
PA15\ (JTDI).Signal=GPXTI15
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=KEY_ADC1
PA2.Signal=ADCx_INP14
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=KEY_ADC2
PA3.Signal=ADCx_INP15
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=INDUCTOR3
PA4.Signal=ADCx_INP18
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=ADC_SPARE2
PA5.Signal=ADCx_INP19
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=MOTOR_L_PWM
PA6.Signal=S_TIM13_CH1
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=FAN_PWM
PA7.Signal=S_TIM14_CH1
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=VBAT_ADC
PB0.Signal=ADCx_INP9
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=ADC_SPARE1
PB1.Signal=ADCx_INP5
PB10.GPIOParameters=GPIO_Pu
PB10.GPIO_Pu=GPIO_PULLUP
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.GPIOParameters=GPIO_Pu
PB11.GPIO_Pu=GPIO_PULLUP
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.GPIOParameters=PinState,GPIO_Label
PB12.GPIO_Label=WIFI_CS
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB13.GPIOParameters=GPIO_Speed
PB13.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB14.GPIOParameters=GPIO_Speed
PB14.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB15.GPIOParameters=GPIO_Speed
PB15.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB5.GPIOParameters=PinState,GPIO_Label
PB5.GPIO_Label=LED_EXT
PB5.PinState=GPIO_PIN_RESET
PB5.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=SPARE_PWM2
PB8.Signal=S_TIM16_CH1
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=SPARE_PWM1
PB9.Signal=S_TIM17_CH1
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=INDUCTOR1
PC0.Signal=ADCx_INP10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=INDUCTOR2
PC1.Signal=ADCx_INP11
PC13.GPIOParameters=GPIO_PuPd,GPIO_Label
PC13.GPIO_Label=KEY
PC13.GPIO_PuPd=GPIO_PULLDOWN
PC13.Signal=GPIO_Input
PC14-OSC32_IN\ (OSC32_IN).Mode=LSE-External-Oscillator
PC14-OSC32_IN\ (OSC32_IN).Signal=RCC_OSC32_IN
PC15-OSC32_OUT\ (OSC32_OUT).Mode=LSE-External-Oscillator
PC15-OSC32_OUT\ (OSC32_OUT).Signal=RCC_OSC32_OUT
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=GRAY_ADC
PC4.Signal=ADCx_INP4
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=INDUCTOR4
PC5.Signal=ADCx_INP8
PC6.GPIOParameters=GPIO_PuPd,GPIO_Label
PC6.GPIO_Label=ENC_R_A
PC6.GPIO_PuPd=GPIO_PULLUP
PC6.Signal=S_TIM3_CH1
PC7.GPIOParameters=GPIO_PuPd,GPIO_Label
PC7.GPIO_Label=ENC_R_B
PC7.GPIO_PuPd=GPIO_PULLUP
PC7.Signal=S_TIM3_CH2
PD10.GPIOParameters=PinState,GPIO_Label
PD10.GPIO_Label=LCD2_BLK
PD10.PinState=GPIO_PIN_SET
PD10.Signal=GPIO_Output
PD14.GPIOParameters=GPIO_Label
PD14.GPIO_Label=MOTOR_R_PWM
PD14.Signal=S_TIM4_CH3
PD15.GPIOParameters=PinState,GPIO_Label
PD15.GPIO_Label=WIFI_RST
PD15.PinState=GPIO_PIN_SET
PD15.Signal=GPIO_Output
PD3.GPIOParameters=PinState,GPIO_Label
PD3.GPIO_Label=IMU_CS
PD3.PinState=GPIO_PIN_SET
PD3.Signal=GPIO_Output
PD9.GPIOParameters=PinState,GPIO_Label
PD9.GPIO_Label=LCD2_RST
PD9.PinState=GPIO_PIN_SET
PD9.Signal=GPIO_Output
PE0.GPIOParameters=GPIO_Label
PE0.GPIO_Label=GRAY_IO3
PE0.Signal=GPIO_Output
PE1.GPIOParameters=GPIO_Label
PE1.GPIO_Label=GRAY_IO4
PE1.Signal=GPIO_Output
PE10.GPIOParameters=GPIO_Label
PE10.GPIO_Label=LCD_BLK
PE10.Mode=PWM Generation2 CH2N
PE10.Signal=TIM1_CH2N
PE11.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PE11.GPIO_Label=LCD_CS
PE11.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE11.PinState=GPIO_PIN_SET
PE11.Signal=GPIO_Output
PE12.Mode=Full_Duplex_Master
PE12.Signal=SPI4_SCK
PE12.GPIOParameters=GPIO_Speed
PE12.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE13.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PE13.GPIO_Label=LCD_WR_RS
PE13.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE13.PinState=GPIO_PIN_SET
PE13.Signal=GPIO_Output
PE14.Mode=Full_Duplex_Master
PE14.Signal=SPI4_MOSI
PE14.GPIOParameters=GPIO_Speed
PE14.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE15.GPIOParameters=PinState,GPIO_Label
PE15.GPIO_Label=MOTOR_R_DIR
PE15.PinState=GPIO_PIN_RESET
PE15.Signal=GPIO_Output
PE3.GPIOParameters=PinState,GPIO_Label
PE3.GPIO_Label=LED_BLUE
PE3.PinState=GPIO_PIN_RESET
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Label
PE4.GPIO_Label=GRAY_IO1
PE4.Signal=GPIO_Output
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE5.GPIOParameters=GPIO_Speed
PE5.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE6.GPIOParameters=GPIO_Label
PE6.GPIO_Label=GRAY_IO2
PE6.Signal=GPIO_Output
PE7.GPIOParameters=PinState,GPIO_Label
PE7.GPIO_Label=MOTOR_L_DIR
PE7.PinState=GPIO_PIN_RESET
PE7.Signal=GPIO_Output
PE8.GPIOParameters=PinState,GPIO_Label
PE8.GPIO_Label=DL1B_XS
PE8.PinState=GPIO_PIN_RESET
PE8.Signal=GPIO_Output
PE9.GPIOParameters=PinState,GPIO_Label
PE9.GPIO_Label=LCD2_CS
PE9.PinState=GPIO_PIN_SET
PE9.Signal=GPIO_Output
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=480000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom
